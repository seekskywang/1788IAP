# Keil uVision project project.uvproj, settings and files
target Open1788 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=870 --no-multibyte-chars
  c include: ..\Libraries\Core\CM3\CoreSupport;..\Libraries\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\Libraries\Drivers\include;..\User;..\Libraries\BoardSupport;..\User\UseDisp;..\User\Globalvalue;..\Libraries\Drivers\include;..\User\Include;..\User\Fat;..\User\Host;..\User\MassStorage;..\User\rtc;..\User\IAP
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Output\project.sct
  group User
    ../User/EX_SDRAM/: EX_SDRAM.c
    ../User/: main.c timer.c
    ../User/LCD/: lpc177x_8x_lcd.c logo.c AsciiLib.c
    ../User/TouchPanel/: TouchPanel.c
    ../User/UseDisp/: use_disp.c
    ../User/Key/: key.c
    ../User/Test/: test.c
    ../User/Globalvalue/: GlobalValue.c
    ../User/IAP/: IAP.c
  group Startup
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CMS
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    ../Libraries/Core/CM3/CoreSupport/: core_cm3.c
  group Drivers
    ../Libraries/Drivers/source/: lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_clkpwr.c lpc177x_8x_ssp.c lpc177x_8x_uart.c debug_frmwrk.c lpc177x_8x_pinsel.c lpc177x_8x_eeprom.c lpc177x_8x_rtc.c
  group fat
    ../User/Fat/: usbhost_fat.c
  group host
    ../User/Host/: usbhost_lpc17xx.c
  group MassStorage
    ../User/MassStorage/: usbhost_ms.c
  group rtc
    ../User/rtc/: rtc.c
